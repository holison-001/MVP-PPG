# Repository holison-001/MVP-PPG

File README.md (part):

# 현재 작업 자료 (2026-10-19)

- PPG 원본: [회로도](kicad/ppg_pcb_v08.kicad_sch), [PCB](kicad/ppg_pcb_v08.kicad_pcb).
- UART 연결 보드 원본: [회로도](kicad/ppg_uart_adapter/ppg_uart_adapter_v01.kicad_sch), [PCB](kicad/ppg_uart_adapter/ppg_uart_adapter_v01.kicad_pcb), [설계 설명](kicad/ppg_uart_adapter/README.md).
- 업체 전달용 UART 추가 소요 BOM: [PPG 양식 적용본](kicad/MVP-UART_BOM_20261013.xlsx). UART 1개당 14종·25개, 제작 수량 10개에서 250개다. 제작 수량에 따라 필요 수량이 자동 계산되며, 미지정 품번 7종은 검토사항 시트에 표시했다.
- 최신 제조 자료: 아래의 2026-10-09 PPG 10개 + UART 10개 패널 거버 및 부품 좌표 Excel.

위 UART BOM의 비교·양식 기준인 [PPG BOM 2026-10-06](kicad/MVP-PPG_BOM_20261006.xlsx)은 C17 추가 전 이력이다. UART 추가 소요 수량에서 기존 PPG 수량을 차감하지 않는다. 아래 날짜별 검증과 제조 출력은 각 작업 시점의 기록이며, 백업과 임시 파일은 로컬에 보관한다.

# PPG 10 + UART 10 — 10 mm 가이드바 패널 (2026-10-09)

사용자 지정 사진의 형식으로 **10세트(보드 20개), 2열×5행, 157×177mm** 패널을 만들었다. 상·하 10mm 가이드바, Ø3mm 가이드 홀 4개, 양면 피듀셜 각 3개, 실제 연결 탭 90개와 Ø2mm 라우팅 슬롯을 생산 거버에 반영했다. 단품 회로·배치·배선은 유지했다.

[10세트 최종 거버 ZIP](manufacturing/20261009_PPG_UART_10sets_GuideRails10mm/PPG_UART_10sets_GuideRails10mm_Gerber_20261009.zip) · [10세트 부품 좌표 Excel](manufacturing/20261009_PPG_UART_10sets_GuideRails10mm/PPG_UART_10세트_부품좌표_20261009.xlsx) · [패널 도면](manufacturing/20261009_PPG_UART_10sets_GuideRails10mm/PANEL_LAYOUT.png) · [제조·분리 방법](manufacturing/20261009_PPG_UART_10sets_GuideRails10mm/README_FABRICATION.md).

PPG 외곽 GND 보존을 위해 타공 없는 탭을 적용했고, **조립 후 지그 고정+CNC 절단**으로 분리한다. 실제 연결성·탭 최소 폭 3mm·라우팅 및 절단 경로와 부품/패드/홀 간섭을 검사했다. 좌표는 740개 단품 항목과 가이드/피듀셜 10개다. 기존 1+1 출력은 아래의 이력으로 보존하며 최신 제조 패키지와 혼용하지 않는다.

# PPG 1 + UART 1 — 연배열용 거버와 좌표 Excel (2026-10-09)

사용자 지시에 따라 최신 PPG 1개와 UART 연결 보드 1개의 거버·드릴 및 부품 좌표 Excel을 생성했다. 6층·공칭 0.8mm, 보드 사이 3mm, 완성 보드 전체 경계 68.5×25mm다. 기존 외곽 GND와 배치를 보존하는 제조사 CAM용 닫힌 외곽 2개이며, 지지 탭·가이드바·툴링·분리 방식은 제조사가 확정해야 한다.

[연배열 거버·드릴 ZIP](manufacturing/20261009_PPG_UART_1plus1/PPG_UART_1plus1_Gerber_Drill_20261009.zip) · [부품 좌표 Excel](manufacturing/20261009_PPG_UART_1plus1/PPG_UART_부품좌표_20261009.xlsx) · [배열 도면](manufacturing/20261009_PPG_UART_1plus1/ARRAY_LAYOUT.png) · [제조 메모](manufacturing/20261009_PPG_UART_1plus1/README_FABRICATION.md).

거버 13개 층의 형상·극성 및 원본 대비 드릴 168개 좌표를 검증했다. PTH Ø0.25mm 164개, NPTH Ø3mm 4개다. Excel은 74개 항목(실장 56, 납땜 패드 14, 고정홀 4)의 개별·배열 좌표와 면·회전각을 포함한다. 원본 PCB는 변경하지 않았으며, 제조 발주·GitHub 업로드는 수행하지 않았다. 아래는 직전 작업 기록이다.

# PPG / UART — 기본 비아 드릴 Ø0.25mm 및 예외 승인 규칙 (2026-10-09)

현재 작업 원본은 `kicad/ppg_pcb_v08.kicad_pcb`와 `kicad/ppg_uart_adapter/ppg_uart_adapter_v01.kicad_pcb`이다. PPG 64개, UART 100개 비아 모두 외경 Ø0.50mm / 드릴 Ø0.25mm로 적용했다. 프로젝트 최소값·비아 프리셋·DRC·생성기 기본값을 일치시켰다. 현재 승인된 Ø0.20mm 예외는 없다.

**Ø0.20mm 비아는 적용 전에 반드시 사용자 승인을 받는다.** 대상 보드·비아 위치·네트·필요 사유·제작비 영향을 설명하고 명시적 승인을 받은 뒤, 승인된 비아에만 검사 예외를 등록한다. 기본 생성값은 Ø0.25mm로 유지한다. 작업 규칙은 [AGENTS.md](AGENTS.md)에 기록했다.

PPG는 드릴 50개를 변경하고, 홀 간격 확보를 위해 배선이 붙지 않은 GND 스티칭 비아 2개만 각각 0.110mm, 0.015mm 이동했다. 부품 배치와 신호 배선은 유지했다. UART는 드릴 93개만 변경했으며 나머지 PCB 내용은 백업과 바이트 단위로 동일하다. UART 고정홀 Ø3mm 4개와 주변 Ø11mm 조립 영역은 유지했다. 두 보드 모두 전층 GND 채움을 재계산했다.

KiCad 검사: 두 보드 모두 **DRC 오류 0 / 미연결 0 / 신규 경고 0**. UART 경고·회로도 불일치 0. PPG는 변경 전부터 있던 일반 경고 5건(실크 외곽 4건, U2 라이브러리 차이 1건)과 별도 회로도 속성 경고 9건(Voltage 8건, Tolerance 1건)을 유지한다. PPG 기존 ESD 자동 검사에는 D8 패드 내부에서 만나는 배선을 패드 제거 뒤에도 남겨 두는 한계로 동일한 경고 1건이 발생하며, 이번 비아 변경 전후 결과는 같다. 세부 검사와 변경 좌표는 [검증 기록](docs/verification_via_025_20261009/), UART 최신 검사는 [연결 보드 검사](kicad/ppg_uart_adapter/pcb_verification.json)에 보관했다.

독립 검사에서 PPG의 42개 부품·패드·기존 배선과 UUID 보존, 최소 홀 사이 간격 0.256187mm, GND 11/11 영역 연결과 1~5층 외곽 연속성을 확인했다. TVS의 실제 패드 영역 안 동박을 제거하는 별도 검사에서는 SWDIO·SWCLK·NRST 3개 경로 모두 차단되어 기존 ESD 접점 통과를 확인했다([독립 검사](docs/verification_via_025_20261009/ppg_independent.json)).

수정 전 백업: `backups/before_via_drill_025_20261009_200410/`. 이번 작업에서는 거버 생성이나 GitHub 업로드를 하지 않았다. 아래 내용은 이전 작업 당시 기록이다.

# SleepBud PPG PCB v0.8 — C17 변경 배치 재배선 (2026-10-08)

사용자가 저장한 C17 바닥면 (20.5000,19.9000)mm/90° 배치를 유지하고, 이동한 GND 패드와 기존 5V 비아·배선의 간섭을 해소했습니다. 5V_LED 및 GND의 연결 경로를 다시 정리했습니다. C17은 100nF, 미터 0603이며 핀 1=5V_LED, 핀 2=GND입니다.

간섭이 있던 5V 비아를 제거하여 전체 비아는 66→65개입니다. C17 전원은 1.138mm, GND는 0.830mm 직선으로 연결했습니다. C1의 1.933mm 연결 중 1.145mm는 선폭 0.30mm, 간격이 좁은 0.788mm 구간은 0.15mm입니다. 기존 부품과 다른 네트 배선을 유지하는 경로를 택해 5V_LED 동박 총길이는 10.382→11.589mm로 1.207mm 늘었습니다.

기존 42개 부품의 위치·각도·패드 형상과 연결을 보존하고, 변경 범위를 5V_LED/GND 동박으로 제한했습니다. 사용자가 조정한 SCL/SDA 등 다른 신호 배선과 회로도·프로젝트·규칙은 유지했습니다. 전층 GND를 다시 채웠고 15/15 GND 영역 연결, 1~5층 외곽 GND 연속성을 확인했습니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. 42개 부품·125개 번호 핀의 회로도/PCB 일치, 다중 핀 네트 연결, 기존 ESD 경로 및 부품 간섭 검사를 통과했습니다.

[C17 배선 전후](docs/review_C17_reroute_20261008/placement_reroute_comparison.png) · [검증 기록](docs/verification_C17_reroute_20261008/). PCB SHA256: `eae91e981d70ecab493e7879cb164b4153b4c0e78430ac3255dfbea034b25f30`. 백업: `backups/20261008_before_C17_reroute/kicad_before_reroute.zip`. 거버 생성과 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — C17 PCB 추가 (2026-10-08)

최신 회로도에 추가된 C17을 PCB에 반영했습니다. 값은 100nF, 풋프린트는 Capacitor_SMD:C_0201_0603Metric(미터 0603, 0.6×0.3mm), 핀 1은 5V_LED, 핀 2는 GND입니다. C17은 바닥면 (20.7500,19.6550)mm/-90°에 배치하고 전원과 GND를 연결했습니다. 회로도의 C17 Description 필드는 복사된 문구인 "U2 VDD bypass"로 남아 있으나, PCB에는 실제 회로도 네트인 5V_LED–GND를 반영했습니다.

기존 41개 부품의 배치·패드와 모든 기존 배선 형상을 보존했습니다. 회로도·프로젝트·규칙 파일도 변경하지 않았으며, C17 항목을 부품 데이터에 추가했습니다. 전층 GND를 다시 채웠고, 14/14 GND 영역 연결과 1~5층 외곽 GND 연속성을 확인했습니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. 총 42개 부품·125개 번호 핀의 회로도/PCB 일치, 네트 연결과 기존 ESD 경로를 검사했습니다. C17 조립 영역과 주변 부품 간섭 검사를 통과했습니다.

[C17 배치 보기](docs/review_C17_20261008/placement_reroute_comparison.png) · [검증 기록](docs/verification_C17_20261008/). PCB SHA256: `b397c72e3ba9275c58eccc9b854cc602f6b2ea16302c17b6da636f57b90675ac`. 백업: `backups/20261008_before_C17_addition/kicad_before_reroute.zip`. 거버 생성과 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — RXN/RXP 패드 교환 및 재배선 (2026-10-08)

사용자가 변경한 R3 (14.1029,17.0)mm/90°, R7 (15.6,17.6)mm/180°, R8 (15.6,16.3)mm/180° 배치를 유지했습니다. 요청에 따라 바닥면 외부 패드 J6/RXN은 위쪽 (15.0655,13.9497)mm, J5/RXP는 아래쪽 (14.8181,19.6172)mm으로 서로 위치를 바꿨습니다. 각 패드의 참조번호·네트·각도는 보존했으며 나머지 39개 부품과 탑면 센서는 움직이지 않았습니다.

RXN/RXP 및 수신 IC까지의 RXN_RCV/RXP_RCV 경로를 재배선했습니다. RXP는 J5→R7→U6.6(A), RXN은 J6→R8→U6.4(B)로 연결하고, R3.1은 RXP, R3.2는 RXN의 연결을 유지했습니다. 사용자가 수정한 SCL 배선을 포함한 다른 네트의 배선 형상과 회로도는 보존했습니다.

수신 네트 4개 동박 길이 합계 19.139→14.801mm. 전체 비아 65→63개. 길이는 비아 수직 길이를 제외한 값입니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. 전층 GND 채움 완료, 13/13 GND 동박 영역 연결. 부품 간 조립 영역·몸체·패드 간섭 및 극성 검증 통과. 123핀 회로도 연결, 다중 핀 23네트와 기존 ESD 3경로도 검사했습니다. 6층 구성, 2층 무배선, 외곽 GND와 선폭·비아 규칙을 유지했습니다.

[배선 전후](docs/review_placement_reroute_20261008e/placement_reroute_comparison.png) · [검증 기록](docs/verification_placement_reroute_20261008e/). PCB SHA256: `2ef282c3a06786d3a7ee80a30bc4c60e2382d900a44287dbae603c8d80d230de`. 백업: `backups/20261008_before_placement_reroute_e/kicad_before_reroute.zip`. 거버 생성과 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — C11/C15 수정 배치 재배선 (2026-10-08)

사용자가 옮긴 C11은 NRST 배선 통로 확보를 위해 바닥면에서 아래로 0.20mm 미세 조정하여 (18.0,19.6)mm/180°에 배치했습니다. U4는 조립 간격과 원형 보드 외곽 여유를 확보하도록 오른쪽 0.40mm, 아래로 0.20mm 옮겨 (18.7257,21.7439)mm/180°에 배치했습니다. 앞서 허용한 바닥면 간섭 미세 조정 범위이며 C15 (19.4,19.4)mm/0°와 U1·D8을 포함한 나머지 39개 부품은 유지했습니다. 전체 151개 패드의 형상·네트를 보존하고, 영향을 받은 전원·GND·NRST 경로를 정리했습니다.

C11/C15의 전원 연결과 MCU 급전을 다시 정리하고, 이전 위치로 향하는 불필요한 배선을 제거했습니다. 5V_LED의 잘게 나뉜 꺾임은 직선·원호로 정리했습니다. NRST는 외부 패드→D8 신호 접점→MCU 순서가 유지되는지 접점 제거 검사를 통과했습니다.

저장된 PCB의 실제 형상 기준으로 같은 면 부품 간 조립 영역·몸체·패드 겹침은 0건입니다. U4 몸체와 원형 보드 외곽 사이 여유는 0.1048mm, 동박 패드 여유는 0.5585mm입니다. U4 조립 영역 표시(Courtyard)는 외곽 밖으로 0.2108mm 돌출하며(이전 0.1834mm), 실제 부품 몸체는 보드 안에 있습니다.

평면 배선 합계: 3.3V 40.650→36.175mm, 5V_LED 10.536→9.351mm, 12V 14.724→14.163mm, NRST 5.564→5.200mm. 전체 비아 65→65개. 길이는 비아 수직 길이를 제외한 동박 합계이며, 모든 네트가 짧아졌다는 의미는 아닙니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. 전층 GND 채움, 13/13 GND 동박 영역 연결, ESD 3경로·회로도 123핀·다중 핀 23네트 검사 통과. 2층 무배선, 1~5층 외곽 GND, 선폭·비아 규칙을 유지했습니다. 회로도·프로젝트·규칙과 관련 없는 배선은 보존했습니다.

[배선 전후](docs/review_placement_reroute_20261008d/placement_reroute_comparison.png) · [검증 기록](docs/verification_placement_reroute_20261008d/). PCB SHA256: `bbd74454cdfd2f07445fb08227b9e11855be98583af45f1e497f3e75ff5221ce`. 변경 전 백업: `backups/20261008_before_placement_reroute_d/kicad_before_reroute.zip`. 거버 생성과 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — 3.3V 전체 경로 정리 (2026-10-08)

사용자가 수정한 C14 배치와 SWCLK 경로를 포함해 41개 부품의 위치·각도·면 및 신호 배선을 그대로 유지했습니다. 3.3V 연결망 전체를 다시 구성해 중복 급전 루프, 중앙 VREF 주변 우회와 서쪽의 긴 돌아가는 경로를 정리했습니다. U3–C16은 직결하고 필요한 방향 전환에는 원호를 적용했습니다. C14 전원 비아와 이전 꼬리 배선을 정리해 GND 패드와의 접촉을 해소했습니다.

3.3V 평면 배선 합계 **50.095 → 40.764 mm**, **18.6% 감소**. 4층 3.3V는 **35.293 → 26.266 mm**, 동박 요소 45→27개입니다. 전원 비아는 8→8개이며, 전체 비아는 65개입니다. 길이는 비아 수직 길이를 제외한 평면 동박 합계입니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. 전층 GND 채움, 15/15 GND 동박 영역 연결, ESD 3경로·회로도 123핀·다중 핀 23네트 검사 통과. 2층 무배선, 1~5층 외곽 GND, 선폭·비아 규칙을 유지했습니다. 회로도·프로젝트·규칙은 변경하지 않았습니다.

[3.3V 배선 전후](docs/review_3V3_cleanup_20261008c/3V3_cleanup_comparison.png) · [검증 기록](docs/verification_3V3_cleanup_20261008c/). PCB SHA256: `2f48cc14bab60c231189b33674a6b2a69fc755beff8a993c0c3906d5b9a2893a`. 변경 전 백업: `backups/20261008_before_3V3_cleanup/kicad_before_reroute.zip`. 거버 생성과 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — U3/R4/R5/C6/C16 수정 배치 재배선 (2026-10-08)

사용자가 조정한 U3, R4, R5, C6, C16을 포함해 41개 부품의 위치·각도·면과 151개 패드 형상·네트를 그대로 유지했습니다. 변경 전 파일은 `backups/20261008_before_placement_reroute_b/kicad_before_reroute.zip`에 백업했습니다.

이동 전 패드로 향하는 배선을 제거하고 UART_TX, TXP/TXN, 3.3V와 GND 귀환을 새 배치에 맞춰 연결했습니다. 이동한 패드와 겹쳐 신호 네트로 재지정된 기존 GND 비아/배선도 제거하고 필요한 GND 연결을 다시 확보했습니다. TXP는 바닥면으로 연결하고 TXN은 3층을 이용합니다. 새 배치의 평면 배선 합계는 TXP 5.765 mm, TXN 7.755 mm, UART_TX 9.604 mm입니다. 기존 위치와 경로 조건이 다르므로 모든 신호의 길이가 줄었다는 의미는 아닙니다. 전체 비아는 65개입니다.

C16의 GND 비아는 (24.15,15.85)mm, 3.3V 비아는 (24.65,15.35)mm로 나눠 배치했습니다. 전원 연결의 0.650mm 병목 구간만 0.15mm 선폭을 적용하고 양끝은 0.30mm, 4층 공급선은 0.40mm를 유지했습니다. 기존 동쪽 C6 전원 분기를 제거했고, R4 전원은 0.760mm 직선입니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. 전층 GND 채움, 15/15 GND 동박 영역 연결, ESD 3경로·회로도 123핀·다중 핀 23네트 검사 통과. 2층 무배선, 1~5층 외곽 GND, 선폭·비아 규칙을 확인했습니다. 회로도·프로젝트·규칙과 관련 없는 배선은 보존했습니다.

[배선 전후](docs/review_placement_reroute_20261008b/placement_reroute_comparison.png) · [검증 기록](docs/verification_placement_reroute_20261008b/). PCB SHA256: `91a72755b21ff8630c9eac5422dce37eba7e7a8c27bb0fce6ad39a48cbc9a3b1`. 거버 생성과 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — 수정 배치 C5/R2/R1 재배선 (2026-10-08)

[현재 PCB](kicad/ppg_pcb_v08.kicad_pcb)에 사용자가 저장한 C5 (21.2,16.2)mm/180°, R2 (21.2,16.9)mm/0°, R1 (21.2,17.6)mm/0° 배치를 그대로 유지해 배선했습니다. 전체 41개 부품의 위치·각도·면 및 151개 패드의 형상·네트를 보존했습니다.

기존 저항 위치로 향하던 B면 배선 10개를 직선 2개로 바꿨습니다. SDA는 기존 비아를 분기점으로 활용해 MCU에서 비아까지의 배선을 공유하고, SCL은 MCU에서 새 R2로 직결했습니다. SDA **6.850→5.904 mm**, SCL **7.860→7.320 mm**, VREF **2.037→1.589 mm**로 단축했습니다. 3.3V와 VREF 비아는 기존 두 자리의 역할을 교환했고, 전체 비아는 **65개 유지**입니다.

C5 GND는 기존 C4 GND 귀환을 공유하며, C5에서 비아까지 실제 경로는 1.781→1.612mm입니다. 새 3.3V 비아 급전을 위해 4층 0.40mm 배선을 국소 수정해 3.3V 전체 길이는45.095→47.042mm로 늘었습니다. 전체 평면 배선 합계는 183.782→183.126mm입니다. 센서 쪽 기존 I2C 경로는 다른 신호와의 간섭 및 추가 변경 비용을 검토한 뒤 유지했습니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. 전층 GND 채움 완료, 16/16 GND 동박 영역 연결, ESD 3경로·회로도 123핀·다중 핀 23네트 검사 통과. 2층 무배선, 1~5층 외곽 GND, 선폭·비아 규칙을 유지했습니다.

[변경 전후](docs/review_placement_route_20261008/placement_route_comparison.png) · [검증 기록](docs/verification_placement_route_20261008/). PCB SHA256: `4a753412db677bffd4155f628a6ae2fa6ba472ef047550a04ff7c33ec5107719`. 변경 전 백업은 `backups/20261008_before_R1_R2_C5_reroute/kicad_before_R1_R2_C5.zip`입니다. 회로도·프로젝트·규칙은 변경하지 않았으며 거버와 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — TXP/TXN 저항 위치 교환 (2026-10-08)

[현재 PCB](kicad/ppg_pcb_v08.kicad_pcb)에서 R5(TXP)와 R6(TXN)의 위치를 맞바꾸고 관련 4개 네트를 재배선했습니다. 부품번호·저항값(22Ω/1005)·회로 연결은 유지했습니다. R5는 (24.7408,16.8914)mm/315°, R6는 (23.7,18.2)mm/270°입니다.

TXP 배선은 **12.233 → 4.939 mm**, TXN은 **7.752 → 7.464 mm**로 줄었습니다. 합계 **19.984 → 12.402 mm, 37.94% 단축**이며 TX 비아는 **6 → 2개**입니다. 저항에서 J3/J4까지 모두 B면 직결이고, TXP 전체도 B면 연결입니다. TXN 드라이버는 3층 직선과 양쪽 짧은 B면 연결로 구성했습니다. 기존 5층 TX 배선은 제거했습니다. 길이는 비아 수직 길이를 제외한 평면 동박 길이입니다.

사용자가 옮긴 R4/C5의 방향과 배치 의도를 유지하면서 R4는 (+0.20,+0.20)mm, C5는 (0,+0.05)mm 미세 조정했습니다. 두 조립 여유 영역 겹침, VREF 비아 간격 문제, 미연결 4곳을 해결했습니다. 모든 탑면 부품은 고정했고 나머지 부품·관련 없는 동박을 보존했습니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건 유지. ESD 3경로·회로도 123핀·다중 핀 23네트 연결을 확인했습니다. 전층 GND 채움 완료, 16/16 GND 영역 연결, 층·외곽 GND·선폭·비아 정책 통과. 전체 비아는 65개입니다.

[변경 전후](docs/review_tx_swap_20261008/tx_swap_comparison.png) · [검증 기록](docs/verification_tx_swap_20261008/). PCB SHA256: `245b0b48098faec4ebdd3d13e3f7ad531b1e78041a6bfc9b882eddd679ae5507`. 변경 전 파일은 `backups/20261008_before_TX_resistor_swap/kicad_before_TX_swap.zip`에 백업했습니다. 거버와 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — U2 서측 이동 및 C4 배선 정리 (2026-10-08)

[현재 PCB](kicad/ppg_pcb_v08.kicad_pcb)에 U2의 9시 방향 1.8 mm 이동을 반영했습니다. C4는 바닥면 북쪽으로 옮기고 R1/R2/R4/C1/C15/D8의 위치 또는 방향과 관련 배선을 조정했습니다. U1을 포함한 모든 탑면 부품은 고정했습니다. C4의 U1.4(VLDO) 배선은 **3.153 → 2.345 mm**로 짧아졌습니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0 · 기존 경고 5건 유지.** 신규 부품 몸체/조립 여유 영역 간섭이 없고, 기존 C11/U5 및 C14/U5 조립 여유 영역 겹침은 늘어나지 않았습니다. ESD 접점 경로 3곳, 회로도 핀 123개, 다중 핀 네트 23개 연결을 확인했습니다. 전층 GND를 재채움했고 15/15 동박 연결 영역이 GND 단자에 연결됩니다. 2층 무배선, 1~5층 외곽 GND, 최소 선폭/비아 규칙을 유지했습니다. 비아는 71 → 69개입니다.

[배치·C4 경로 전후](docs/review_u2_c4_20261008/u2_c4_comparison.png) · [검증 기록](docs/verification_u2_c4_20261008/). 네트별 길이 증감은 검증 기록의 independent_verification.json에 보관했습니다. 회로도·프로젝트·설계 규칙은 변경하지 않았습니다.

PCB SHA256: `0db206e568dc9441220bb5e9327dbec5d7b70599d49fd8e6ac2166f2f1b90cc9`. 변경 전 백업은 `backups/20261008_before_U2_C4_apply/kicad_before_U2_C4.zip`입니다. 배치와 배선 검토용 로컬 원본에 저장했으며 거버와 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — 배선 연결 정리 (2026-10-07)

[현재 PCB](kicad/ppg_pcb_v08.kicad_pcb)에 사용자 최신 배치를 유지하면서 NRST의 D8 우회와 C13의 12V 접속을 정리했습니다. **J9 → 기존 진입 비아 → D8 신호패드 접점 → 추가 보호측 비아 → 3층 → U2.4** 순서입니다. D8은 바닥면 (16.6,19.0)mm / 90°를 유지하고, 보호측 비아 0.50/0.20mm를 (17.15,19.20)mm에 추가했습니다. TVS는 신호–GND 병렬 보호소자입니다.

C13.1–12V 비아를 폭 0.15mm / 길이 0.5521mm로 직접 연결했습니다. 사용자 복구한 비아–U4.8 입력 배선도 유지했습니다. D8 GND는 기존 비아까지 폭 0.30mm / 길이 0.8591mm로 연결했습니다. 전체 41개 부품·패드·기존 비아 위치를 보존했으며 R4 10kΩ UART_TX 풀업도 그대로입니다. 비아는 70→71개입니다.

**DRC 오류 0 · 미연결 0 · 회로도 불일치 0 · 기존 경고 5건**입니다. D6·D7·D8 ESD 접점 경로 검사 통과, D8 패드 영역의 동박을 제거하는 별도 검사에서도 우회 경로가 없음을 확인했습니다. 전층 GND를 재채움했고 15/15 GND 연결 영역이 J2.1에 도달합니다. 외곽 GND·층·선폭·비아 규칙과 회로도 핀 일치 검사도 통과했습니다.

[배선 수정 전후](docs/review_routing_connections_20261007/connections_before_after.png) · [검증 기록](docs/verification_routing_connections_20261007/).

PCB SHA256: `6f5485a1f81b4cb11914d462fbb74e58576903f7c1595e6b5ecb7f60054ed806`. 로컬 원본에 저장했습니다. 거버·드릴·BOM 및 GitHub 업로드는 이번 작업 범위에 포함하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — SCL 1층 직결 (2026-10-06)

[현재 PCB](kicad/ppg_pcb_v08.kicad_pcb)의 R2 쪽 SCL 비아에서 U1.2까지 1층에서 바로 연결했습니다. 1층 우회는 1.999→0.798mm, 3층 우회는 5.753→4.182mm로 줄였습니다. SCL 총 길이는 9.352→6.580mm(2.773mm 단축)이며 불필요한 SCL 비아 1개를 제거했습니다. 전체 비아는 69개입니다.

41개 부품·패드·나머지 비아와 다른 넷의 배선은 그대로입니다. U1 고정, D8 바닥면 유지, TVS를 먼저 거치는 연결을 보존했습니다. **DRC 오류 0 · 미연결 0 · 회로도 불일치 0**, 기존 경고 5건은 동일합니다. ESD 경로 3곳, 전층 GND 연결(13/13 영역), 외곽 GND 및 선폭·비아·층 규칙도 통과했습니다.

[SCL 수정 전후](docs/review_scl_top_20261006/scl_before_after.png) · [검증 기록](docs/verification_scl_top_20261006/).

PCB SHA256: `5c4c9d1eabbfb2f3db410d5fa80927defbf1545fe8b773ff937ddca9fa6ac063`. 로컬 원본 저장 완료. 거버·드릴·BOM 생성 및 GitHub 업로드는 진행하지 않았습니다.

<details>
<summary>Previous work records / 이전 작업 기록</summary>

# SleepBud PPG PCB v0.8 — TVS 배선 순서 수정 (2026-10-06)
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
## KiCad design kicad/ppg_pcb_v08.kicad_pcb

Parts:
C1: 10 µF; C_0402_1005Metric; Voltage 6.3 V
C4, C5, C12, C14: 1 µF; C_0201_0603Metric; Voltage 6.3 V
C6, C7, C11, C17: 100 nF; C_0201_0603Metric
C13: 1 µF; C_0402_1005Metric; Voltage 25 V
C15, C16: 100 nF; C_0201_0603Metric; Voltage 16 V
D1: SPHV15-01ETG; TVS_SOD882_1x0.6; MPN SPHV15-01ETG
D6, D7, D8: ESD351DPYR; TI_DPY0002A_1x0.6; MPN ESD351DPYR
FB1: BLM15PX601SN1D; L_0402_1005Metric; MPN BLM15PX601SN1D
J1: 12V; CablePad_D1.2
J2: GND; CablePad_D1.2
J3: TXP; CablePad_D1.2
J4: TXN; CablePad_D1.2
J5: RXP; CablePad_D1.2
J6: RXN; CablePad_D1.2
J7: SWDIO; TestPad_D0.8_Front
J8: SWCLK; TestPad_D0.8_Front
J9: NRST; TestPad_D0.8_Front
J10: GND; TestPad_D0.8_Front
J11: 3V3_VTREF; TestPad_D0.8_Front
R1, R2: 4.7 kΩ; R_0201_0603Metric
R3: 120 Ω; R_0402_1005Metric; Tolerance 1%; MPN CRCW0402120RFKEDHP
R4: 10 kΩ; R_0201_0603Metric
R5, R6, R7, R8: 22 Ω; R_0402_1005Metric; MPN CRCW040222R0JNEDHP
U1: MAXM86161EFD+; MAXM86161_OLGA-14
U2: STM32C011F6U6; ST_UFQFPN-20_3x3mm_P0.5mm
U3: XR33194ESBTR; TSOT23-6_MaxLinear; MPN XR33194ESBTR
U4: MCP1703A-5002E/MC; DFN-8-1EP_2x3mm_P0.5mm_EP0.61x2.2mm
U5: MCP1703A-3302E/MC; DFN-8-1EP_2x3mm_P0.5mm_EP0.61x2.2mm
U6: XR33183ESBTR; TSOT23-6_MaxLinear; MPN XR33183ESBTR

Connections:
3V3: C6.1, C7.1, C11.1, C12.1, C14.1, C15.1, C16.1, J11.1, R1.2, R2.2, R4.2, U2.2 (VDD), U3.2 (VCC), U3.3 (DE), U5.1 (VOUT), U6.1 (VCC)
5V_LED: C1.1, C17.1, U1.5 (VLED), U4.1 (VOUT), U5.8 (VIN)
12V: C13.1, FB1.2, U4.8 (VIN)
/12V_IN: D1.1 (K), FB1.1, J1.1
/LDO_EN: U1.3 (LDO_EN), U2.12 (PA7)
/NRST: D8.1 (IO/K), J9.1, U2.4 (PF2-NRST)
/RXN: J6.1, R3.2, R8.2
/RXN_RCV: R8.1, U6.4 (B)
/RXP: J5.1, R3.1, R7.2
/RXP_RCV: R7.1, U6.6 (A)
/SCL: R2.1, U1.2 (SCL), U2.18 (PB6/I2C1_SCL)
/SDA: R1.1, U1.1 (SDA), U2.19 (PB7/I2C1_SDA)
/SWCLK: D7.1 (IO/K), J8.1, U2.17 (PA14/SWCLK/BOOT0)
/SWDIO: D6.1 (IO/K), J7.1, U2.16 (PA13/SWDIO)
/TXN: J4.1, R6.2
/TXN_DRV: R6.1, U3.4 (Z)
/TXP: J3.1, R5.2
/TXP_DRV: R5.1, U3.6 (Y)
/UART_RX: U2.15 (PA10/USART1_RX), U6.3 (RO)
/UART_TX: R4.1, U2.14 (PA9/USART1_TX), U3.1 (DI)
/VLDO: C4.1, U1.4 (VLDO)
/VREF: C5.1, U1.12 (VREF)
GND: C1.2, C4.2, C5.2, C6.2, C7.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.2 (A), D6.2 (GND/A), D7.2 (GND/A), D8.2 (GND/A), J2.1, J10.1, U1.9 (PGND), U1.10 (GND_DIG), U1.11 (GND_ANA), U2.3 (VSS), U3.5 (GND), U4.4 (GND), U4.9 (EP), U5.4 (GND), U5.9 (EP), U6.2 (GND), U6.5 (~EN)

Notes on the sheet:
R3: 120 Ω / 1% at the local RX cable pair.
v0.8 / MAXM86161 + STM32C011 / full-duplex UART over RS-422
Additional 3V3 bypass / 0603 MLCC
03 UART / RS-422 LINK
J1 raw supply -> D1 / FB1 (section 04)
01 PPG SENSOR
VLDO bypass
VLED bulk
RS-422 bus TVS omitted; 22 Ω series retained. D1 protects supply, D6-D8 protect SWD. IEC immunity requires physical validation.
02 MCU + I2C PULL-UPS
RX / controller to earbud
C1: 5V_LED / U4 output bulk capacitor (section 01). D1 clamps raw 12V_IN; FB1 feeds filtered 12V.
Cable: 12V, GND, TXP, TXN, RXP, RXN. Piezo coax bypasses this PCB. Matching net labels are connected.
TX / earbud to controller
SleepBud | PPG sensor board
VREF bypass
Enhanced fail-safe: UART_RX high.
05 RS-422 CABLE PADS
A3 | FUNCTIONAL SCHEMATIC
U3: DE = 3V3. U6: /EN = GND.
06 SWD TEST PADS + ESD
04 INPUT PROTECTION + POWER

Board: 6 copper layers, 13.5 x 13.5 mm, 42 parts (34 on the bottom side), 23 nets.

## KiCad design kicad/ppg_uart_adapter/ppg_uart_adapter_v01.kicad_pcb

File kicad/ppg_uart_adapter/README.md (part):

# PPG UART 연결 보드 v0.1

기존 PPG와 전선 6개로 연결하는 전이중 RS-422 ↔ 3.3V UART 변환 보드다. 같은 작업 폴더에 별도 KiCad 프로젝트로 작성했다. 외부 9V를 PPG와 공유하고, 사용자 지정 LD1117-3.3V로 이 보드의 통신부와 UART 포트용 3.3V를 만든다. MCU는 추가하지 않는다.

회로도와 PCB 배치·배선을 완료했다. 외곽 고정홀 4개와 홀 주변 Ø11mm 조립 여유를 반영했다. 현재 연결 보드는 52×25mm 직사각형, 6층·0.8mm 기준이다. 모든 SMT 부품과 전선 납땜 패드는 B.Cu에 배치했다. KiCad 기본 위에서 본 좌표 기준 PPG 6핀은 하단 왼쪽 외곽, UART 4핀은 하단 오른쪽 외곽, 9V 입력은 상단 외곽이다. 연결 보드는 기존 PPG와 별도 프로젝트로 관리하며 제조 패널·거버는 아직 생성하지 않았다.

## 파일

- `ppg_uart_adapter_v01.kicad_pro`: KiCad 프로젝트
- `ppg_uart_adapter_v01.kicad_sch`: 편집 가능한 회로도
- `ppg_uart_adapter_v01.kicad_pcb`, `.kicad_dru`: 배선 완료 PCB와 설계 규칙
- `pcb_drc.json`, `pcb_verification.json`: 최종 DRC·회로도 일치 및 GND·ESD 경로 검사
- `preview/pcb_01_top.png` ~ `pcb_06_bottom.png`: 6개 층 검토 이미지. 바닥면은 실물 부품면 방향으로 좌우 반전했다.
- `build_adapter_pcb.py`, `pcb_geometry.py`, `mounting_holes.py`, `edge_ports.py`: PCB 생성 코드. KiCad Python과 Shapely 필요. 수정본을 재생성하기 전 반드시 백업한다.
- `preview/ppg_uart_adapter_v01.svg`, `.png`: 전체 회로도 미리보기
- `BOM.csv`: 부품표. Value와 Voltage/Tolerance/Dielectric를 분리했다. 일부 범용 수동소자의 주문 품번은 미지정이다.
- `Adapter.kicad_sym`, `Adapter.pretty`, 라이브러리 테이블: 프로젝트 로컬 심벌·풋프린트
- `erc.json`, `netlist.xml`, `verification.json`: KiCad ERC, 실제 넷리스트와 독립 대조 검사
- `design_manifest.json`: 기대 핀별 연결. `build_adapter.py`는 이 새 연결 보드만 생성한다. 사용자가 회로도를 편집한 뒤에는 백업 없이 재생성하지 않는다.

## 연결

| 단자 | 핀 | 신호 / 방향 |
| --- | --- | --- |
| J1 전원 | 1 / 2 | 외부 9V 입력 / GND |
| J2 PPG | 1 / 2 | PPG 공급 9V / GND |
| J2 PPG | 3 / 4 | PPG TXP / TXN → 연결 보드 수신기 U3 A / B |
| J2 PPG | 5 / 6 | 연결 보드 송신기 U2 Y / Z → PPG RXP / RXN |
| J3 UART | 1 | 3.3V 전원 출력 |
| J3 UART | 2 | TX_OUT: 연결 보드 출력 → 외부 장치 RX |
| J3 UART | 3 | RX_IN: 외부 장치 TX → 연결 보드 입력 |
| J3 UART | 4 | GND |

J2의 1~6번은 기존 PPG J1~J6에 각각 연결한다. PPG의 `12V_IN`/`12V`는 기존 네트 이름으로, 실제 공칭 공급은 9V다. 이 보드 J3.1은 입력이 아닌 LDO 전원 출력이다. 세 연결부는 우선 도금 구리 납땜 패드(지름1.2mm·피치1.8mm·솔더 페이스트 없음) 풋프린트로 지정했다.

## 적용 부품과 출력 안정화

회로도 Value는 `22 Ω`, `10 kΩ`, `100 nF`, `22 µF`처럼 숫자와 단위 사이를 띄워 통일했다. 전압·허용오차·유전체는 숨김 Voltage/Tolerance/Dielectric 필드와 BOM 열에 보존한다. 미지정 정격은 추정하여 채우지 않는다. IC·TVS·비드는 기존 MPN의 전체 품번을 표시한다.

- U1: **ST LD1117S33TR / SOT-223**, 핀1 GND, 핀2·탭 3V3, 핀3 9V_LDO.
- R1~R8과 모든 MLCC는 **미터1608(1.6×0.8mm, 인치0603)**. **R9는 미터3216(3.2×1.6mm, 인치1206)**. 탄탈은 사용하지 않는다.
- C1: 10µF/25V 입력 벌크. C3: 100nF/25V 입력 바이패스. C4/C5: 100nF/25V 통신 IC 바이패스.
- C2/C6/C7/C8: TDK **C1608X5R1A226M080AC**, 각각22µF/10V/X5R/±20%, 병렬4개. 공칭 합계88µF.
- R9: 1Ω / 미터3216(1206). 연결은 `3V3 → R9 → COUT_BULK → 병렬 MLCC4개 → GND`다. **R9는 부하 전원선에 들어가지 않는다.**
- U2 XR33194ESBTR 송신기 DE=3V3, U3 XR33183ESBTR 수신기 /EN=GND로 상시 활성화한다. R6 10kΩ은 호스트 입력 미구동 시 DI를 UART 유휴 HIGH로 유지한다.
- 수신 종단 R1 120Ω은 PPG TXP/TXN 도착부에만 둔다. 반대 방향 종단은 PPG에 있는 R3 120Ω을 사용한다. 차동선에는22Ω, UART 측에는100Ω 직렬저항을 둔다.
- 차동선에 Bourns CDSOT23-SM712 두 개, UART TX/RX에 TI ESD351DPYR 두 개를 적용했다. PCB에서는 외부 패드→TVS 접점→직렬저항→IC 순서와 짧은 GND 귀환을 구현한다. 9V 입력 TVS는 이 초안에 임의 선정하지 않았다.

LD1117 고정형의 출력 커패시터 최소값은10µF이다. ST 기술 답변은 MLCC 사용 시0.5~10Ω 직렬저항을 안내하므로 이 설계에서는1Ω을 적용했다. 22µF MLCC의 공칭값을 실효 용량으로 취급하지 않았다. 보관한 TDK 제조사 특성 문서의 DC 바이어스 그래프에서3.3V 부근은 부품당 약7~8µF로 읽히므로4개 합계는 약28~32µF인 **참고치**다. 이는 제조사 보증 최솟값이나 실물 안정성 시험 결과가 아니다.

## 검증

KiCad10.0.5 ERC 오류0·경고0. 실제 넷리스트의28개 부품·73개 핀을 기대 연결과 대조했고, 모든 풋프린트를 실제 로드하여 핀 번호를 확인했다. LD1117 탭=핀2, UART 방향, 종단 위치, R9의 커패시터 분기 연결, R1~R8 및 모든 MLCC의1608 규격, R9의3216 규격을 확인했다. SVG와 PNG를 렌더링하여 한글·기호·텍스트가 용지와 도면 표제란 안에서 겹치지 않는지 검토했다. 검증 범위는 회로도 연결과 부품 매핑이며 PCB DRC나 실물 ESD/부하 시험을 수행했다는 의미는 아니다.

표기 통일 후 native 넷리스트를 다시 내보내 73핀·17넷이 변경 전과 동일함을 확인했다. 심벌·핀·배선의 UUID와 배치 좌표도 동일하다. 현재 회로도·BOM·manifest 값/정격이 일치하고, 생성기를 파일 출력 전까지 메모리에서 평가한 결과도 현재 회로도와 일치한다. 저항9개를 포함한 모든28부품의 실제 풋프린트를 로드해 패드 번호를 확인했다.

## PCB 배선 검증 — 2026-10-09

- 28개 부품, 74개 실제 패드(회로도 73핀; U1의 OUT 리드와 탭이 모두 핀2).
- L1·L2·L3·L5는 배선 없는 GND 면. L4는 3V3 분배와 GND, L6는 부품 사이 짧은 배선과 GND.
- 전층 GND 6개 영역 모두 공통 GND에 연결. L1~L5 외곽 GND는 연속된 폐루프이며, 외곽에서0.36~0.55mm 안쪽 띠는 완전히 GND로 덮인다.
- 최소 실제 신호 배선0.20mm, 설정 최솟값0.15mm. 비아61개: GND56개(외곽/내부 추가 스티칭37개), 전원5개. 비아 규격은 아래 최신 드릴 변경 절을 적용한다.
- J2의 차동4선과 J3의 UART2선은 TVS 신호패드 접점을 통과한 뒤 내부로 이어진다. TVS 전단 비아 없음. TVS 패드 영역의 동박을 제거하면 각 외부→내부 경로가 차단되는 것을 기하 검사로 확인했다.
- DRC 오류0·경고0, 미연결0, 회로도 불일치0. 부품 courtyard·몸체·패드 간섭0, 비아와 SMT패드의 동박/드릴 겹침0.
- 중복 분기 배선을 제거하고 FB1→LDO 입력을 직선으로 연결했다. R9는1Ω/3216이며 출력 커패시터 전용 분기에 유지했다.

검증은 KiCad 규칙, 회로도 일치와 저장된 PCB 기하 검사 범위다. 기구 외형 확정·제조 패널·거버·실물 시험은 이번 작업에 포함하지 않았다.

## 고정홀 초기 반영 — 2026-10-09 (Ø11 변경 전 기록)

- H1~H4: **Ø3.0mm NPTH 4개**, 전기 연결 없는 기구 가공 항목. 회로도·BOM·PCB 모두 반영했다.
- 외형 **42×22mm**, 홀 중심은 각 외곽에서 **4mm**, 중심 간 피치 **34×14mm**. PCB 좌표는 H1(97,104), H2(131,104), H3(97,118), H4(131,118)mm이다.
- 각 홀 주변 **Ø6.5mm**를 양면 부품 조립 여유 및 전층 배선·비아·푸어 금지 영역으로 확보했다. 풋프린트의 Ø6.0mm 원은 나사 머리 기준 표시이며, 특정 나사/와셔의 실제 치수가 지정된 것은 아니다.
- 기존 28개 전자부품, 82개 배선, 61개 비아의 위치·형상·네트·UUID를 보존했다. 외곽에 GND 비아16개를 추가해 총77개(GND72, 전원5)가 되었다.
- 전층 GND를 다시 채웠으며 L1~L5 외곽 GND 연속성과 TVS 접점을 지나는 6개 신호 경로를 재검증했다. 나사 여유 영역과 부품 간섭0건, ERC·DRC 오류/경고0건, 미연결0건, 회로도 불일치0건.
- 이전 작업 전체 백업: `../../backups/adapter_before_mounting_holes_20261009_182851/ppg_uart_adapter/`.
- `mounting_layout.json`에 치수·홀 좌표·추가 비아 좌표를 기록했다. 앞의 PCB 배선 검증 절은 고정홀 추가 전 기준이며 이 절과 최신 JSON 보고서가 현재 상태다.

## 고정홀 주변 Ø11mm 확대 — 2026-10-09 (외곽 포트 이동 전 기록)

- 실제 고정홀은 **Ø3.0mm NPTH 4개**를 유지하고, 양면 조립 영역 및 6층의 배선·비아·푸어 금지 영역을 **Ø11mm**로 확대했다.
- 외형 **52×25mm**, 외곽 좌표 x88~140/y98.5~123.5mm. 홀 중심은 H1(94.5,105), H2(133.5,105), H3(94.5,117), H4(133.5,117)mm이며 중심 피치 **39×12mm**, 각 외곽에서 중심까지 **6.5mm**이다.
- Ø11 영역끼리 세로1mm, Ø11 영역에서 PCB 외곽까지1mm 여유를 확보했다. 기존 전자부품28개·신호/전원/GND 배선82개·원래 비아61개는 유지했다.
- 앞선 42×22mm 확장부의 GND 비아16개만 교체하고 새 외곽에36개를 배치했다. 현재 총97개(GND92개, 전원5개)다.
- H1~H4 기구 심벌의 풋프린트와 설명, 회로도 치수 메모, BOM 및 설계 데이터를 동기화했다. 실제 드릴 지름과 전기적 연결은 바꾸지 않았다.
- 수정 전 전체 백업: `../../backups/adapter_before_mounting11_20261009_183719/ppg_uart_adapter/`.
- 현재 크기·좌표는 `mounting_layout.json`, ERC·DRC와 기하 검증은 최신 JSON 보고서를 따른다. 위의 Ø6.5 및 42×22mm 항목은 이전 작업 기록이다.

## 외곽 연결부 재배치 — 2026-10-09 (현재 상태)

- 보드52×25mm와 Ø3 NPTH 4개/Ø11 조립 여유는 유지하고, 실제 전선 패드를 현재 보드 외곽으로 이동했다. 모든 부품과 패드는 B.Cu다.
- J1 9V 입력: 상단, pin1(102.5,99.75)mm. J2 PPG6: 하단, pin1(101.5,122.25)mm. J3 UART4: 하단, pin1(121.1,122.25)mm. 각 포트는0°이며 번호가 왼쪽부터 증가한다(위에서 본 좌표). 바닥면 미리보기는 실물 부품면 방향으로 반전하므로 좌우가 바뀐다.
- 패드 동박 끝과 외곽 사이0.65mm를 남겼으며, 각 패드에서 보드 밖으로 직선으로 전선을 뺄 수 있다. 인출 경로에 다른 부품·고정홀 조립 영역이 없다.
- PPG 입력은 외곽 패드→D1/D2 TVS 접점→종단/직렬저항→U3/U2 순으로 수직 배선했다. UART는 외곽 패드→D3/D4→R7/R8 순서이며, 작은 TVS는 GND패드가 신호 직진 경로에 놓이지 않도록 옆으로 배치했다.
- L3에 UART 내부신호2개, L4에3V3/공유9V를 배선했다. L2는 무배선 GND, 전층 GND 연결 및 L1~L5 외곽 연속성을 유지했다.
- LDO·비드·입출력 벌크부품 및 고정홀13개 위치/값/네트와 지정 LDO 동박을 보존했다. 이동한 통신 IC의 바이패스 MLCC도 전원핀 근처에 다시 배치했다.
- 배선86개·비아100개. DRC 오류0·경고0, 미연결0, 회로도 불일치0. 모든 비아100개와 SMT패드74개의 동박/드릴 겹침0건(동일넷 포함). 전층 GND6/6 연결 및 ESD6경로 검사 통과.
- 전기적 회로와 핀 배정은 변경하지 않았다. `edge_port_layout.json`과 `placement_and_routing.json`에 최종 배치·출선 방향을 기록했다.
- 수정 전 전체 백업: `../../backups/adapter_before_edge_ports_20261009_184715/ppg_uart_adapter/`.

## 부품 근거

- [ST LD1117 데이터시트](https://www.st.com/resource/en/datasheet/ld1117.pdf)
- [ST 기술 답변: MLCC와 출력 직렬저항](https://community.st.com/power-management-53/ld1117-input-output-capacitor-requirements-160103)
- [TDK C1608X5R1A226M080AC 공식 제품 사양](https://product.tdk.com/en/search/capacitor/ceramic/mlcc/info?part_no=C1608X5R1A226M080AC)
- [TDK 제조사 특성 문서의 유통사 보관본](https://media.ret.hu/datasheet/C1608X5R1A226M080AC.pdf), 작성일2023-11-29. 동일 품번의 현재 규격은 위 공식 제품 페이지와 대조했다. 보관 파일: `reference/C1608X5R1A226M080AC_TDK_20231129.pdf`, 그래프: `reference/C1608X5R1A226M080AC_curves.png`.
- [XR33194 제조사 데이터시트](https://www.maxlinear.com/ds/xr33193_xr33194_xr33195.pdf)
- [XR33183 제조사 제품 페이지](https://www.maxlinear.com/product/interface/serial-transceivers/rs-485-rs-422/xr33183)
- [Bourns SM712 데이터시트](https://www.bourns.com/pdfs/CDSOT23-SM712.pdf)
- [TI ESD351 데이터시트](https://www.ti.com/lit/ds/symlink/esd351.pdf)

## 비아 드릴 기본 규격 변경 — 2026-10-09

- 기본 비아 규격은 **외경 Ø0.50mm / 드릴 Ø0.25mm**다. 신호·GND·전원에 동일하게 적용한다. 현재 비아100개 중 기존 Ø0.20mm 드릴93개를 Ø0.25mm로 변경하고 기존 Ø0.25mm 7개는 유지했다.
- 비아 위치·외경·네트·UUID, 배선86개, 부품32개, Ø3.0mm NPTH 고정홀4개, Ø11mm 기구 여유 영역은 유지했다.

Parts:
C1: 10 µF; C_0603_1608Metric; Voltage 25 V
C2, C6, C7, C8: 22 µF; C_0603_1608Metric; Voltage 10 V; Tolerance 20%; MPN C1608X5R1A226M080AC
C3, C4, C5: 100 nF; C_0603_1608Metric; Voltage 25 V
D1, D2: CDSOT23-SM712; SOT-23; MPN CDSOT23-SM712
D3, D4: ESD351DPYR; TI_DPY0002A_1x0.6; MPN ESD351DPYR
FB1: BLM15PX601SN1D; L_0402_1005Metric; MPN BLM15PX601SN1D
H1, H2, H3, H4: Ø3.0 mm NPTH; MountingHole_3mm_Clearance11mm
J1: 9V INPUT; WirePads_1x02_P1.8mm_D1.2
J2: PPG / 6 WIRES; WirePads_1x06_P1.8mm_D1.2
J3: UART / 3.3V OUT; WirePads_1x04_P1.8mm_D1.2
R1: 120 Ω; R_0603_1608Metric; Tolerance 1%
R2, R3, R4, R5: 22 Ω; R_0603_1608Metric
R6: 10 kΩ; R_0603_1608Metric
R7, R8: 100 Ω; R_0603_1608Metric
R9: 1 Ω; R_1206_3216Metric
U1: LD1117S33TR; SOT-223-3_TabPin2; MPN LD1117S33TR
U2: XR33194ESBTR; TSOT23-6_MaxLinear; MPN XR33194ESBTR
U3: XR33183ESBTR; TSOT23-6_MaxLinear; MPN XR33183ESBTR

Connections:
/3V3: C4.1, C5.1, J3.1, R6.1, R9.1, U1.2 (VOUT / TAB), U2.2 (VCC), U2.3 (DE), U3.1 (VCC)
/9V_LDO: C1.1, C3.1, FB1.2, U1.3 (VIN)
/9V_SHARED: FB1.1, J1.1, J2.1
/COUT_BULK: C2.1, C6.1, C7.1, C8.1, R9.2
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.3 (GND), D2.3 (GND), D3.2 (GND/A), D4.2 (GND/A), J1.2, J2.2, J3.4, U1.1 (GND), U2.5 (GND), U3.2 (GND), U3.5 (~EN)
/PPG_RXN: D2.2 (IO2), J2.6, R5.2
/PPG_RXP: D2.1 (IO1), J2.5, R4.2
/PPG_TXN: D1.2 (IO2), J2.4, R1.2, R3.1
/PPG_TXP: D1.1 (IO1), J2.3, R1.1, R2.1
/RXN_IC: R3.2, U3.4 (B (-))
/RXP_IC: R2.2, U3.6 (A (+))
/RX_IN: D4.1 (IO/K), J3.3, R8.1
/TXN_IC: R5.1, U2.4 (Z (-))
/TXP_IC: R4.1, U2.6 (Y (+))
/TX_OUT: D3.1 (IO/K), J3.2, R7.2
/UART_RX_IC: R6.2, R8.2, U2.1 (DI)
/UART_TX_IC: R7.1, U3.3 (RO)

Notes on the sheet:
PPG 연결 보드 / 6-wire RS-422 to 4-pin 3.3V UART
공통 9V 입력 · LD1117-3.3V · R1~R8·MLCC 1608 / R9 3216 / 탄탈 없음 · 동일 6층 0.8mm 패널 제작 예정
01 전원 / 9V shared supply
U1 TAB = 3V3 (GND 아님) / 9V_SHARED → J2.1 출력: 1608 MLCC 22 µF × 4 + R9 1 Ω (커패시터 분기에만 직렬)
02 UART 커넥터 / 연결 보드 기준
J3.2 TX_OUT → 외부 장치 RX J3.3 RX_IN ← 외부 장치 TX J3.1은 전원 출력
03 PPG 수신 / PPG → UART TX_OUT
PPG 기존 J1~J6와 번호대로 연결 PPG의 12V_IN 표기는 공칭 9V 입력 차동쌍: TXP/TXN, RXP/RXN
TVS 접점 → 직렬저항 → IC 120 Ω은 이 수신쌍에만 배치
04 PPG 송신 / UART RX_IN → PPG
C4는 U2, C5는 U3 전원핀 근처 배치. GND 공통. PPG RXP/RXN의 120 Ω 종단은 PPG 보드에 이미 있음.
05 고정홀 / 기구 가공
고정홀 4 × Ø3.0 mm NPTH PCB 52 × 25 mm / 홀 피치 39 × 12 mm 머리 조립 여유 Ø11 mm
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
Board: 6 copper layers, 52.0 x 25.0 mm, 32 parts (32 on the bottom side), 17 nets.

## Code that names these connections

File kicad/design_v08.py (part):

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COMPONENTS = {
    "U1": dict(value="MAXM86161EFD+", lib="custom", fp="MAXM86161_OLGA-14", side="F", pos=(0.0, 0.0), rot=0,
               desc="PPG optical module (G/R/IR LED + PD + AFE), single supply, internal 1.8 V LDO, I2C 0x62",
               pins={"1": "SDA", "2": "SCL", "3": "LDO_EN", "4": "VLDO", "5": "5V_LED", "6": None, "7": None,
                     "8": None, "9": "GND", "10": "GND", "11": "GND", "12": "VREF", "13": None, "14": None}),
    "U2": dict(value="STM32C011F6U6", lib="Package_DFN_QFN", fp="ST_UFQFPN-20_3x3mm_P0.5mm", side="B", pos=(0.27, -4.0), rot=0,
               desc="MCU, USART1 (PA9/PA10) <-> RS-422 driver/receiver, I2C1 (PB6/PB7) -> PPG; USART bootloader over the link",
               pins={"1": None, "2": "3V3", "3": "GND", "4": "NRST", "5": None, "6": None, "7": None, "8": None, "9": None, "10": None,
                     "11": None, "12": "LDO_EN", "13": None, "14": "UART_TX", "15": "UART_RX", "16": "SWDIO", "17": "SWCLK",
                     "18": "SCL", "19": "SDA", "20": None}),
    "U3": dict(value="XR33194", mpn="XR33194ESBTR", manufacturer="MaxLinear", side="B", pos=(3.0, 0.1), rot=-90,
               desc="RS-422 driver, 2.5 Mbps slew-rate limited, VCC 3.3 V +/-5%; pin 2 VCC and pin 3 DE tied to 3V3; TSOT-23-6",
               datasheet="${KIPRJMOD}/../datasheet/pdf/XR33193_XR33194_XR33195_MaxLinear.pdf",
               pins={"1": "UART_TX", "2": "3V3", "3": "3V3", "4": "TXN_DRV", "5": "GND", "6": "TXP_DRV"}, **TSOT236),
    "U6": dict(value="XR33183", mpn="XR33183ESBTR", manufacturer="MaxLinear", side="B", pos=(-3.05, -0.82), rot=90,
               desc="RS-422 receiver, 52 Mbps, enhanced open/short/idle fail-safe RO high; VCC 3.0-5.5 V; pin 2 GND and active-low EN pin 5 tied to GND; external R3 120 ohm receive termination; TSOT-23-6",
               datasheet="${KIPRJMOD}/../datasheet/pdf/XR33180_XR33181_XR33183_XR33184_MaxLinear.pdf",
               pins={"1": "3V3", "2": "GND", "3": "UART_RX", "4": "RXN_RCV", "5": "GND", "6": "RXP_RCV"}, **TSOT236),
    "U4": dict(value="MCP1703A-5002E/MC", lib="Package_DFN_QFN", fp="DFN-8-1EP_2x3mm_P0.5mm_EP0.61x2.2mm", side="B", pos=(-1.85, 4.37), rot=90,
               desc="LDO 12 V -> 5 V (VLED)", pins={"1": "5V_LED", "2": None, "3": None, "4": "GND", "5": None, "6": None, "7": None, "8": "12V", "9": "GND"}),
    "U5": dict(value="MCP1703A-3302E/MC", lib="Package_DFN_QFN", fp="DFN-8-1EP_2x3mm_P0.5mm_EP0.61x2.2mm", side="B", pos=(1.85, 4.37), rot=90,
               desc="LDO 5 V -> 3.3 V", pins={"1": "3V3", "2": None, "3": None, "4": "GND", "5": None, "6": None, "7": None, "8": "5V_LED", "9": "GND"}),
    # ---- passives
    "C1": dict(value="10uF 6.3V X5R", side="B", pos=(0.0, 2.17), rot=180, pins={"1": "5V_LED", "2": "GND"}, desc="VLED bulk / LDO1 output", **C0402),
    "C4": dict(value="1uF 6.3V", side="B", pos=(-0.85, 0.85), rot=90, pins={"1": "VLDO", "2": "GND"}, desc="U1 VLDO bypass", **C0201),
    "C5": dict(value="1uF 6.3V", side="B", pos=(0.85, 0.85), rot=90, pins={"1": "VREF", "2": "GND"}, desc="U1 VREF bypass", **C0201),
    "R1": dict(value="4.7k", side="B", pos=(-0.85, -0.65), rot=90, pins={"1": "SDA", "2": "3V3"}, desc="I2C SDA pull-up", **R0201),
    "R2": dict(value="4.7k", side="B", pos=(0.85, -0.65), rot=90, pins={"1": "SCL", "2": "3V3"}, desc="I2C SCL pull-up", **R0201),
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    # RS-422 additions; reviewed physical positions are applied in PLACEMENT below.
    "R3": dict(value="120/1%", mpn="CRCW0402120RFKEDHP", manufacturer="Vishay",
               datasheet="${KIPRJMOD}/../datasheet/pdf/Vishay_CRCW-HP_e3.pdf", side="B", pos=(-3.0, 2.3), rot=90,
               pins={"1": "RXP", "2": "RXN"},
               desc="RS-422 receive termination across cable RXP/RXN at U6; 120 ohm +/-1%, 0402, 0.2 W high-pulse series; cable-side of R7/R8; prototype pulse performance requires validation", **R0402),
    "R4": dict(value="10k", side="B", pos=(2.75, -2.1), rot=90,
               pins={"1": "UART_TX", "2": "3V3"},
               desc="UART_TX idle-state pull-up to 3V3, 10 kohm +/-5%, 0201; max static loss 1.21 mW at 3.465 V; keeps U3 DI high during MCU reset; MPN pending", **R0201),
    # ---- cable solder pads Ø1.2 (r <= 5.85)
    "J1": dict(value="12V", lib="custom", fp="CablePad_D1.2", side="B", pos=(-4.39, 3.85), rot=180, pins={"1": "12V_IN"}, desc="cable +12 V input, before ESD suppressor and FB1"),
    "J2": dict(value="GND", lib="custom", fp="CablePad_D1.2", side="B", pos=(0.0, 5.85), rot=180, pins={"1": "GND"}, desc="cable GND"),
    "J3": dict(value="TXP", lib="custom", fp="CablePad_D1.2", side="B", pos=(5.6, 1.3), rot=180, pins={"1": "TXP"}, desc="cable RS-422 TX+ (earbud -> controller)"),
    "J4": dict(value="TXN", lib="custom", fp="CablePad_D1.2", side="B", pos=(5.7, -1.0), rot=180, pins={"1": "TXN"}, desc="cable RS-422 TX-"),
    "J5": dict(value="RXP", lib="custom", fp="CablePad_D1.2", side="B", pos=(-5.8, 0.5), rot=180, pins={"1": "RXP"}, desc="cable RS-422 RX+ (controller -> earbud)"),
    "J6": dict(value="RXN", lib="custom", fp="CablePad_D1.2", side="B", pos=(-5.49, -2.0), rot=180, pins={"1": "RXN"}, desc="cable RS-422 RX-"),
    # ---- Front SWD pogo pads: diameter 0.8 mm, 1.27 mm pitch, no paste.
    # Left to right: J9 NRST, J7 SWDIO, J10 GND, J8 SWCLK, J11 3V3_VTREF.
    # J11 senses target voltage for the programmer; J2 remains the back cable GND.
    "J7": dict(value="SWDIO", lib="custom", fp="TestPad_D0.8_Front", side="F", pos=(-1.27, 4.85), rot=0, pins={"1": "SWDIO"}, desc="Front SWD pogo test pad PA13, 0.8 mm, no solder paste"),
    "J8": dict(value="SWCLK", lib="custom", fp="TestPad_D0.8_Front", side="F", pos=(1.27, 4.85), rot=0, pins={"1": "SWCLK"}, desc="Front SWD pogo test pad PA14, 0.8 mm, no solder paste"),
    "J9": dict(value="NRST", lib="custom", fp="TestPad_D0.8_Front", side="F", pos=(-2.54, 4.85), rot=0, pins={"1": "NRST"}, desc="Front reset pogo test pad, 0.8 mm, no solder paste"),
    "J10": dict(value="GND", lib="custom", fp="TestPad_D0.8_Front", side="F", pos=(0.0, 4.85), rot=0, pins={"1": "GND"}, desc="Front SWD ground pogo test pad, 0.8 mm, no solder paste"),
    "J11": dict(value="3V3_VTREF", lib="custom", fp="TestPad_D0.8_Front", side="F", pos=(2.54, 4.85), rot=0, pins={"1": "3V3"}, desc="Front SWD target-voltage reference pogo pad on 3V3, 0.8 mm, no solder paste"),
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
File kicad/ppg_uart_adapter/build_adapter.py (part):

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cap('C3',55.88,64.77,'100nF / 25V','Capacitor_SMD:C_0603_1608Metric','9V_LDO',desc='Place at LD1117 input; metric1608 MLCC')
esr=resistor('R9',151.13,48.26,'1 ohm','3V3','COUT_BULK',footprint='Resistor_SMD:R_1206_3216Metric',desc='LD1117 ceramic output ESR resistor in capacitor branch only; not in load supply path')
wire(u['2'],esr['1']);label('3V3',132.08,48.26)
wire(esr['2'],(245.11,48.26));label('COUT_BULK',174,48.26)
for ref,x in [('C2',165.1),('C6',191.77),('C7',218.44),('C8',245.11)]:
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 wire(p['1'],(x,48.26));junction(x,48.26);stub(p['2'],'GND','D',2.54)
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text('PPG 기존 J1~J6와 번호대로 연결\nPPG의 12V_IN 표기는 공칭 9V 입력\n차동쌍: TXP/TXN, RXP/RXN',12.7,163.83,1.27)

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for ref,y,nc,ni,pinno in [('R2',121.92,'PPG_TXP','RXP_IC','6'),('R3',132.08,'PPG_TXN','RXN_IC','4')]:
 rp=resistor(ref,165.1,y,'22',nc,ni);wire((101.6,y),rp['1']);label(nc,101.6,y);wire(rp['2'],rx[pinno]);label(ni,177.8,y)
rr=resistor('R1',139.7,127,'120 / 1%','PPG_TXP','PPG_TXN',True,desc='Receiving-end termination; match existing PPG120ohm architecture')
wire(rr['1'],(139.7,121.92));wire(rr['2'],(139.7,132.08));junction(139.7,121.92);junction(139.7,132.08)
stub(rx['1'],'3V3','U',2.54);stub(rx['2'],'GND','D',2.54);stub(rx['5'],'GND','L',5.08)
rp=resistor('R7',279.4,127,'100','UART_TX_IC','TX_OUT');wire(rx['3'],rp['1']);label('UART_TX_IC',248.92,127);stub(rp['2'],'TX_OUT','R',7.62)
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stub(d['1'],'PPG_TXP','L',5.08);stub(d['2'],'PPG_TXN','L',5.08);stub(d['3'],'GND','D',2.54)
shunt('D3',320.04,152.4,'TX_OUT')
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
text('04  PPG 송신 / UART RX_IN → PPG',12.7,190.5,1.905)
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rp=resistor('R8',125.73,218.44,'100','RX_IN','UART_RX_IC');stub(rp['1'],'RX_IN','L',12.7);wire(rp['2'],tx['1']);label('UART_RX_IC',168.91,218.44)
pull=resistor('R6',160.02,207.01,'10k','3V3','UART_RX_IC',True);stub(pull['1'],'3V3','U',2.54);wire(pull['2'],(160.02,218.44));junction(160.02,218.44)
stub(tx['2'],'3V3','U',2.54);stub(tx['3'],'3V3','L',5.08);stub(tx['5'],'GND','D',2.54)
for ref,y,ni,nc,pinno in [('R4',213.36,'TXP_IC','PPG_RXP','6'),('R5',223.52,'TXN_IC','PPG_RXN','4')]:
 rp=resistor(ref,279.4,y,'22',ni,nc);wire(tx[pinno],rp['1']);label(ni,248.92,y);stub(rp['2'],nc,'R',10.16)
d=place('D2','SM712',345.44,236.22,'CDSOT23-SM712','Package_TO_SOT_SMD:SOT-23',{'1':'PPG_RXP','2':'PPG_RXN','3':'GND'},'CDSOT23-SM712','Bourns','https://www.bourns.com/pdfs/CDSOT23-SM712.pdf','Transmit pair cable-side protection; far-end termination exists on PPG',props=(355.6,226.06,355.6,229.87))
stub(d['1'],'PPG_RXP','L',5.08);stub(d['2'],'PPG_RXN','L',5.08);stub(d['3'],'GND','D',2.54)
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